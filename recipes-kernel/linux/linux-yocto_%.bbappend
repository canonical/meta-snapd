require recipes-kernel/linux/linux-snapd.inc

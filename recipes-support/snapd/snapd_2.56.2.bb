include snapd.inc

SRC_URI[md5sum] = "5952bd537b14f74aa2c33ecba84e9d9a"
SRC_URI[sha256sum] = "ee4096ef1a74a8d29b4cb7f43d442244beec413c21a517f34476270eb6a59fed"

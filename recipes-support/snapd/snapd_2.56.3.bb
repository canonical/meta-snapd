include snapd.inc
DEFAULT_PREFERENCE = "-1"

SRC_URI[md5sum] = "7c2b0900dbfed98747c283a068a80b0f"
SRC_URI[sha256sum] = "302747ed9e854af1740ee6660be7a17fd36fb4de0e1dedf42a4020b78c6c06fa"

require snapd.inc
require snapd-git.inc

include snapd.inc

SRC_URI[md5sum] = "722be543c98df28ab04df1ade4ab8d38"
SRC_URI[sha256sum] = "22873493d9cd389b7d33775f3af22d663a749ecf53c4b93c03fd880350ee612d"
